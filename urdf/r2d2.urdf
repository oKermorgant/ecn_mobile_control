Commit message: c++ simulator / control

File: urdf/r2d2.urdf (robot description, URDF)
Before this commit: robot r2d2, 14 links, 13 joints
Joints:
- joint carrot_disable: parent base_link -> footprint
